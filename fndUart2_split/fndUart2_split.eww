<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\fndUart2_split.ewp</path>
    </project>
    <batchBuild />
</workspace>
