<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sampleUart2_Timer_1s.ewp</path>
    </project>
    <batchBuild />
</workspace>
