<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sampleUart2_adc1_ch1_ch2_dma.ewp</path>
    </project>
    <batchBuild />
</workspace>
